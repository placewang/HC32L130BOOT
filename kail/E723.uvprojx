# Keil uVision project E723.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\driver\inc;..\mcu\common;..\user\In
  memory RVCT4: ROM 0x0 size 0x2bff
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Source Group 1
    ../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
    ./: startup_hc32l13x.s
  group bsp
    ../user/: bsp_time.c bsp_uart.c
  group user
    ../user/: upgrade..c
  group lib
    ../driver/src/: sysctrl.c ddl.c flash.c bt.c uart.c gpio.c
  group main
    ../main/: main.c
software components: CMSIS:CORE 5.0.1
